# Keil uVision project matrix_keypad.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: matrix_keypad +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: storage_slave.c keypad_main.c serialcomms_slave.c

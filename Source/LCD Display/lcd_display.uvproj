# Keil uVision project lcd_display.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd_display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: storage_master.c asteroid_belt.c earth_defense.c lcd.c lcddisp_main.c serialcomms_master.c
